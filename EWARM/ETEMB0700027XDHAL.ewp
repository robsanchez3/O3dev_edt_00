# IAR project ETEMB0700027XDHAL.ewp, settings and files
configuration ETEMB0700027XDHAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32U599NI ST STM32U599NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U599xx; USE_BPP=24
  ICCARM.CCIncludePath2: ../Core/Inc; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include/; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../Middlewares/Third_Party/CMSIS/RTOS2/Include/; ../Drivers/Vendor/Board/SE21194/Config; ../Drivers/Vendor/Device; ../Drivers/Vendor/Driver; ../Drivers/Vendor/Device/mx25lm51245g; ../Drivers/Vendor/FatFs/source/drivers/sd; ../Drivers/Vendor/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/Vendor/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/touchgfx/framework/include; ../Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/include; ../Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/videos/include; ../TouchGFX/gui/include; ../FATFS/App; ../FATFS/Target; ../Drivers/Vendor/FatFs/source; ../USB_Device/App; ../USB_Device/Target; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../USB_Host/App; ../USB_Host/Target; ../Drivers/Vendor/Device/USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../Core/Inc; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include/; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../Middlewares/Third_Party/CMSIS/RTOS2/Include/; ../Drivers/Vendor/Board/SE21194/Config; ../Drivers/Vendor/Device; ../Drivers/Vendor/Driver; ../Drivers/Vendor/Device/mx25lm51245g; ../Drivers/Vendor/FatFs/source; ../Drivers/Vendor/FatFs/source/drivers/sd; ../Drivers/Vendor/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/Vendor/STM32_USB_Device_Library/Core/Inc; ../USB_Device/App; ../USB_Device/Target; ../FATFS/App; ../FATFS/Target; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../USB_Host/App; ../USB_Host/Target; ../Drivers/Vendor/Device/USB
  OBJCOPY.OOCOutputFile: ETEMB0700027XDHAL.hex
  ILINK.IlinkOutputFile: ETEMB0700027XDHAL.out
  ILINK.IlinkIcfFile: stm32u599xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: ETEMB0700027XDHAL.ipcf
  group Application/EWARM
    ./: startup_stm32u599xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c cordic.c crc.c dcache.c dma2d.c fdcan.c gpu2d.c i2c.c icache.c ltdc.c memorymap.c octospi.c sdmmc.c tim.c usart.c usb_otg.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp nema_hal.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_cordic.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_fdcan.c stm32u5xx_hal_gpu2d.c stm32u5xx_hal_ltdc.c stm32u5xx_hal_ltdc_ex.c stm32u5xx_hal_dsi.c stm32u5xx_hal_ospi.c stm32u5xx_ll_dlyb.c stm32u5xx_ll_sdmmc.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_sdio.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c
  group Drivers/Vendor
    ../Drivers/Vendor/Board/SE21194/Config/: edt_board_config.c se21194_sys_conf.h
    ../Drivers/Vendor/Driver/: edt_bsp_backlight.c edt_bsp_can.c edt_bsp_ctp.c edt_bsp_lcd.c
  group Drivers/Vendor/Components
    ../Drivers/Vendor/Device/ctp/: mxt336u.c mxt640u.c
    ../Drivers/Vendor/Device/mx25lm51245g/: mx25lm51245g.c
  group Drivers/Vendor/FatFs/source
    ../Drivers/Vendor/FatFs/source/: diskio.c ff_gen_drv.c ff.c ffsystem_cmsis_os.c ffunicode.c
    ../Drivers/Vendor/FatFs/source/drivers/sd/: sd_diskio_dma_rtos.c
  group Drivers/Vendor/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/Vendor/STM32_USB_Device_Library
    ../Drivers/Vendor/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Drivers/Vendor/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/Vendor/USB_DEVICE/App
    ../USB_Device/App/: usbd_cdc_if.c usb_device.c usbd_desc.c
  group Drivers/Vendor/USB_DEVICE/Target
    ../USB_Device/Target/: usbd_conf.c
  group TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_arial_20_4bpp_0.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_arial_20_4bpp.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_arial_20_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_40_4bpp.cpp UnmappedDataFont.cpp VectorFontRendererBuffers.cpp
  group TouchGFX/generated/gui_generated
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen2_screen/: Screen2ViewBase.cpp
  group TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp image_example.cpp SVGDatabase.cpp
    ../TouchGFX/generated/images/src/__designer/: image_Blue_Buttons_Round_Edge_small.cpp image_Blue_Buttons_Round_Edge_small_pressed.cpp
  group TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX/gui/screen1_screen
    ../TouchGFX/gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group TouchGFX/gui/screen2_screen
    ../TouchGFX/gui/src/screen2_screen/: Screen2Presenter.cpp Screen2View.cpp
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/lib/core/cortex_m33/IAR8.x/: nemagfx_core_release.a
    ../Middlewares/ST/touchgfx/lib/core/cortex_m33/IAR9.x/: touchgfx_core.a
    ../Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/lib/cortex_m33/IAR8.x/: touchgfx_nema_release.a
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: portasm.s port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
